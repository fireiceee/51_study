# Keil uVision project DS1302clock.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: DS1302clock +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c LCD1602.c LCD1602.h DS1302.c DS1302.h Delay.c Delay.h Timer0_Init.h Timer0_Init.c MatrinKey.c MatrinKey.h
