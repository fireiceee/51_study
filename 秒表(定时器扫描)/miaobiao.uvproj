# Keil uVision project miaobiao.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: miaobiao +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c AT24C02.c Delay.c I2C.c LCD1602.c MatrinKey.c Nixie.c Timer0_Init.c AT24C02.h Delay.h I2C.h LCD1602.h MatrinKey.h Nixie.h Timer0_Init.h Key.c
