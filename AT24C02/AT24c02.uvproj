# Keil uVision project AT24c02.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: AT24c02 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c LCD1602.c Delay.c Delay.h LCD1602.h MatrinKey.h MatrinKey.c I2C.c AT24C02.c I2C.h AT24C02.h
